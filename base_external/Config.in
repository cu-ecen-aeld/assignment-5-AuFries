## base_external/Config.in
```kconfig
source "$BR2_EXTERNAL_BASE_EXTERNAL_PATH/package/aesd-assignments/Config.in"
source "$BR2_EXTERNAL_BASE_EXTERNAL_PATH/package/ldd/Config.in"
```
